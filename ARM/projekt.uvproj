# Keil uVision project projekt.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2131 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: projekt +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x40000000 size 0x2000
  group Source Group 1
    ./: Startup.s 5_kolokwium_skeleton.s
    ../Pictures/: LPC213x.s
